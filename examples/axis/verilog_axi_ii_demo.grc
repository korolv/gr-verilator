options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: length
  id: variable
  parameters:
    value: '200'
  states: {}
- name: num_sigma
  id: variable_qtgui_range
  parameters:
    label: Sigma
    start: '0'
    step: '.1'
    stop: '6'
    value: '2'
    widget: slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: scale1
  id: variable
  parameters:
    value: 0x7fffffff/num_sigma
  states: {}
- name: blocks_float_to_int_0
  id: blocks_float_to_int
  parameters:
    scale: scale1
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: scale1
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: float
    vector: np.random.normal(loc=0.0, scale=1.0, size=length)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '.5'
    grid: 'True'
    label1: Original
    label2: Quantized
    name: '"Signals"'
    nconnections: '2'
    size: length
    srate: samp_rate
    type: float
    width1: '2'
    ymax: '3.5'
    ymin: '-3.5'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: error
    name: f'Error characteristics "{num_sigma}*sigma"'
    size: length
    srate: samp_rate
    type: float
    ymax: '3.5'
    ymin: '-3.5'
  states: {}
- name: verilator_axis_0
  id: verilator_axis
  parameters:
    io_ratio: '1.0'
    type: int
    verilator_options: '""'
    verilogfile: gr-verilator/examples/axis/gr_tb_axis.v
  states: {}

connections:
- [blocks_float_to_int_0, '0', verilator_axis_0, '0']
- [blocks_int_to_float_0, '0', blocks_sub_xx_0, '1']
- [blocks_int_to_float_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_vector_source_x_0, '0', blocks_float_to_int_0, '0']
- [blocks_vector_source_x_0, '0', blocks_sub_xx_0, '0']
- [blocks_vector_source_x_0, '0', qtgui_time_sink_x_0, '0']
- [verilator_axis_0, '0', blocks_int_to_float_0, '0']

metadata:
  file_format: 1
